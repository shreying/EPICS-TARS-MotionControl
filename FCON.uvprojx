# Keil uVision project FCON.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FCON +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\Keil\stm32f10x-stdperiph-lib-master\Libraries\STM32F10x_StdPeriph_Driver\inc;D:\Keil\packs\ARM\CMSIS\6.1.0\CMSIS\Core\Include;D:\Keil\stm32f10x-stdperiph-lib-master\Project\STM32F10x_StdPeriph_Template
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: FC.c
    D:/Keil/stm32f10x-stdperiph-lib-master/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    D:/Keil/stm32f10x-stdperiph-lib-master/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c system_stm32f10x.h
    D:/Keil/stm32f10x-stdperiph-lib-master/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_gpio.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
