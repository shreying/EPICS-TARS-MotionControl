# Keil uVision project aclib.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: adxl345 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\AC;D:\Keil\stm32f1xx-hal-driver-master\Inc;D:\Keil\packs\ARM\CMSIS\6.1.0\CMSIS\Core\Include;D:\Keil\stm32f10x-stdperiph-lib-master\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;D:\Keil\stm32f10x-stdperiph-lib-master\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./AC/: adxl345.c main.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
