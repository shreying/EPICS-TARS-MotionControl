# Keil uVision project IMUSim.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IMUSim +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT=0,STM32F10X_MD
  c include: D:\Keil\packs\Keil\STM32F1xx_DFP\2.4.1\Device\StdPeriph_Driver\inc;.\IMU;D:\Keil\packs\Keil\STM32F1xx_DFP\2.4.1\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./IMU/: main.c adxl345.h gyro.h gyro.c mag.c mag.h orientation.c usart.h usart.c stm32f10x_conf.h orientation.h
    ./: adxl345.c
    D:/Keil/packs/Keil/STM32F1xx_DFP/2.4.1/Device/StdPeriph_Driver/inc/: stm32f10x_rcc.h stm32f10x_usart.h stm32f10x_gpio.h stm32f10x_i2c.h
    D:/Keil/packs/Keil/STM32F1xx_DFP/2.4.1/Device/StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_usart.c
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, Device:Startup 1.0.0
